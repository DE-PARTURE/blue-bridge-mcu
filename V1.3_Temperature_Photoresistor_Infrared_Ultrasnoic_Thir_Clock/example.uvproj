# Keil uVision project example.uvproj, settings and files
target example (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: example +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Basic;.\Hardware;.\User
  group Hardware
    ./Hardware/: IIC.c infrared.c Keyboard.c SMG.c OneWire.c Snoic.c LED.c DS1302.c
  group User
    ./User/: main.c
  group Basic
    ./Basic/: Sys.c
